# Keil uVision project f103vc.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: f103vc +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\core;.\STM32F10x_FWLib\inc;.\user;.\hardware\AD7192;.\hardware\ADG1409;.\hardware\USART;.\hardware\delay;.\hardware\Modbus;.\hardware\time;.\hardware\watchdog
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ./user/: main.c stm32f10x_it.c system_stm32f10x.c
  group core
    ./core/: core_cm3.c startup_stm32f10x_hd.s
  group STM32F10x_FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group hardware
    ./hardware/AD7192/: AD7192.c
    ./hardware/Modbus/: Modbus.c
  group basic
    ./hardware/AD7192/: AD7192_Driver.c
    ./hardware/time/: time.c
    ./hardware/USART/: usart.c
    ./hardware/delay/: delay.c
    ./hardware/watchdog/: wdg.c
    ./hardware/ADG1409/: ADG1409.c
    ./: readme.txt
